# Keil uVision project nrf_test.uvprojx, settings and files
target NRF52840 (5060960::V5.06 update 7 (build 960)::.\arm_compilerv5)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf_test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c include: ..\modules\nrfx\drivers\include;..\integration\nrfx\legacy;.\Application;..\modules\nrfx;..\integration\nrfx;..\components\libraries\util;..\components\drivers_nrf\nrf_soc_nosd;..\components\libraries\log;..\components\libraries\experimental_section_vars;..\components\libraries\log\src;..\modules\nrfx\hal;..\components\libraries\delay
  asm define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group Application
    ./Application/: main.c main.h sdk_config.h it.c
  group NRF_library
    ../integration/nrfx/legacy/: nrf_drv_uart.c
    ../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_gpiote.c
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
