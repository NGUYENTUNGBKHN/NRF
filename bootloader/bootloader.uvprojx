# Keil uVision project bootloader.uvprojx, settings and files
target NRF52840 (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group App_boot
    ./Application/: main.c
  group NRF_Library
    ../integration/nrfx/legacy/: nrf_drv_uart.c
    ../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
